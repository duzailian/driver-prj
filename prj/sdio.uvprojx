# Keil uVision project sdio.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sdio +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\src\arm;..\src\lib;..\src\main;..\src\driver;..\src\middle;..\src\os;..\src\app;..\src\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../src/main/: main.c
  group lib
    ../src/lib/: lib.c
  group arm
    ../src/arm/: core_cm3.c startup_stm32f10x_hd.s
  group driver
    ../src/driver/: driver.c
  group middle
    ../src/middle/: middle.c
  group bsp
    ../src/bsp/: bsp.c
